Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2022-11-10T23:48:55
Made in: SketchUp Pro 2015

# IfcProject, Default Project
Description: Description of Default Project

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 24, 28, 0; RefLongitude: 54, 25, 0; RefElevation: 10 mm

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Building Storey
In: Default Building
Description: Description of Default Building Storey; Elevation: 0 mm

# IfcBuildingElementProxy (8)
In: Default Building Storey
Description: Description of Object
CompositionType - IfcElementCompositionEnum: complex
1. Scellement de tampon - Matériau: Béton

# IfcFlowController, Object
In: Default Building Storey
Description: Description of Object
1. Poste de relevage - Caractéristiques: Non renseigné

# IfcFlowFitting (36)
In: Default Building Storey
Description: Description of Object
Name
14 x  | 1. Elément droit Réhausse de 900 - Matériau: Béton préfabriqué; Diamètre: 1000 mm; Hauteur: 900 mm; Poids: 680 kg
8 x  | 1. Elément de fond de regard - Matériau: Béton préfabriqué; Diamètre: 1000 mm; Hauteur: 485 mm; Poids: 920 kg
 | 1. Elément droit Réhausse de 300 - Matériau: Béton préfabriqué; Diamètre: 1000 mm; Hauteur: 300 mm; Poids: 220 kg
 | 1. Elément droit Réhausse de 450 - Matériau: Béton préfabriqué; Diamètre: 1000 mm; Hauteur: 450 mm; Poids: 340 kg
8 x  | 1. Tête réductrice - Matériau: Béton préfabriqué; Diamètre: 1000 mm; Hauteur: 1000 mm; Poids: 700 kg
2 x  | 1. Elément droit Réhausse de 600 - Matériau: Béton préfabriqué; Diamètre: 1000 mm; Hauteur: 600 mm; Poids: 440 kg
2 x  | Elément droit Réhausse de 1200 - Matériau: Béton préfabriqué; Diamètre: 1000 mm; Hauteur: 1200 mm; Poids: 920 kg

# IfcFlowSegment (9)
In: Default Building Storey
Description: Description of Object
Name | 1. Canalisation gravitaire, Matériau | 1. Canalisation gravitaire, Réseau | 1. Canalisation gravitaire, Diamètre
 | 1. Canalisation sous pression - Matériau: PEHD; Réseau: Eaux usées; Diamètre: Non défini
7 x Grès D200 | Fonte | Eaux usées | 200 mm
 | Fonte | Eaux usées | 200 mm

# IfcFlowTerminal (8)
In: Default Building Storey
Description: Description of Object
1. Tampon de regard 600 - Produit: Tampon de regard [Urbamax 600] - E600; Matériau: Fonte
